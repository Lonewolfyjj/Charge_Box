# IAR project A6901P_Box.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: N32L406CB Nations N32L406CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L40X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\Libraries\n32l40x_std_periph_driver\inc; ..\Libraries\CMSIS\device; ..\Libraries\CMSIS\core; ..\User; ..\rtthread; ..\rtthread\include; ..\rtthread\components\finsh; F:\LiLinsFile\MacrophoneGroup\6902_box\6902_box_app\User\Utility; ..\User\Module\Inc; ..\User\Hal\Inc; ..\User\Driver\Inc; ..\User\App\Inc; ..\rtthread\components\pin; ..\User\Utility\fifo; ..\User\Utility\hup; ..\User\Utility\xor_calc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A6901P_Box.hex
  ILINK.IlinkOutputFile: A6901P_Box.out
  ILINK.IlinkIcfFile: N32L406xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ../Libraries/CMSIS/device/startup/: startup_n32l40x_EWARM.s
    ../Libraries/CMSIS/device/: system_n32l40x.c
  group components/FinSH
    ../rtthread/components/finsh/: cmd.c msh.c shell.c
  group components/Pin
    ../rtthread/components/pin/: pin.c pin.h
  group libarary
    ../Libraries/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_tsc.c n32l40x_usart.c n32l40x_wwdg.c
  group rt_thread_nano
    ../rtthread/: board.c
    ../rtthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../rtthread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group User
    ../User/: main.c n32l40x_it.c
  group User/hal
    ../User/Hal/Src/: hl_hal_console.c hl_hal_gpio.c hl_hal_uart.c
  group User/utility
    ../User/Utility/fifo/: hl_util_fifo.c
    ../User/Utility/hup/: hl_util_hup.c
    ../User/Utility/xor_calc/: hl_util_xor_calc.c
