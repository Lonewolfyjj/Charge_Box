# IAR project box_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32L406CB Nations N32L406CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L40X; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\core; ..\Libraries\CMSIS\device; ..\Libraries\n32l40x_std_periph_driver\inc; ..\User\Driver\Inc; ..\User\Hal\Inc; ..\User; ..\Libraries\FATFS; ..\User\Module\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: box_bootloader.bin
  ILINK.IlinkOutputFile: box_bootloader.out
  ILINK.IlinkIcfFile: N32L406xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/device/startup/: startup_n32l40x_EWARM.s
    ../Libraries/CMSIS/device/: system_n32l40x.c
  group Libarary
    ../Libraries/n32l40x_std_periph_driver/src/: misc.c n32l40x_flash.c n32l40x_gpio.c n32l40x_iwdg.c n32l40x_rcc.c n32l40x_spi.c n32l40x_usart.c
  group Libarary/FATFS
    ../Libraries/FATFS/: diskio.c ff.c
  group User
    ../User/: main.c n32l40x_it.c
  group User/driver
    ../User/Driver/Src/: hl_drv_fatfs.c hl_drv_flash.c hl_drv_internal_flash.c
  group User/hal
    ../User/Hal/Src/: hl_hal_boot_jump.c hl_hal_hard_spi.c hl_hal_uart_dbg.c
  group User/Module
    ../User/Module/Src/: hl_mod_upgrade.c
